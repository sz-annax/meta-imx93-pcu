NXP_DEMO_SRCREV = "95b466a7556832ab3e52d8bd7c3f356d0e92f504"