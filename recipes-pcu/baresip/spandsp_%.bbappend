SRCREV = "0446f4e0c72553f3ea9b50c5333ece6ac980e58d"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-ademco-contactid-fix-fixed-point-declaration.patch"
