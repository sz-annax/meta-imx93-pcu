# IMAGE_INSTALL += "pjproject"

