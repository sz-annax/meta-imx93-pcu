# Append to imx-image-full
IMAGE_INSTALL:append = " alsa-state alsa-lib alsa-utils alsa-tools alsa-plugins"
IMAGE_INSTALL:append = " v4l-utils libv4l"
IMAGE_INSTALL:append = " tslib net-tools tcpdump libubootenv"
IMAGE_INSTALL:append = " helloworld"
IMAGE_INSTALL:append = " qtmultimedia qtmultimedia-plugins qtmultimedia-qmlplugins"
IMAGE_INSTALL:append = " pjproject"
IMAGE_INSTALL:append = " pjsip-test"
IMAGE_INSTALL:append = " pei-imx"
